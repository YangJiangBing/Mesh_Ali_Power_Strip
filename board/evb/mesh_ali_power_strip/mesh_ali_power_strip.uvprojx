# Keil uVision project mesh_ali_power_strip.uvprojx, settings and files
target mesh_ali_strip (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM4_FP ARM
  pack: ARM.CMSIS.5.6.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ESEL ELITTLE
  output: app +hex
  BeforeMake: ..\..\..\tool\before_build_common.bat $K
  BeforeMake: before_build_special.bat
  AfterMake: ..\..\..\tool\after_build_common.bat $J #L @L
  AfterMake: after_build_special.bat
  c flags: Optim=3 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: MESH_DEVICE
  c misc: --gnu --preinclude app_flags.h --bss_threshold=0
  c include: ..\..\..\inc\app;..\..\..\inc\bluetooth\gap;..\..\..\inc\bluetooth\gap\gap_lib;..\..\..\inc\bluetooth\profile;..\..\..\inc\bluetooth\profile\server;..\..\..\inc\bluetooth\profile\client;..\..\..\inc\os;..\..\..\inc\peripheral;..\..\..\inc\platform;..\..\..\inc\platform\cmsis;..\..\..\src\app\mesh\lib;..\..\..\src\app\mesh\lib\lib;..\..\..\src\app\mesh\lib\platform;..\..\..\src\app\mesh\lib\gap;..\..\..\src\app\mesh\lib\cmd;..\..\..\src\app\mesh\lib\model;..\..\..\src\app\mesh\lib\model\ali;..\..\..\src\app\mesh\lib\model\realtek;..\..\..\src\app\mesh\lib\profile;..\..\..\src\app\mesh\lib\utility;..\..\..\src\app\mesh\lib\inc;..\..\..\src\app\mesh\lib\common;..\..\..\src\app\mesh\ali_strip;..\mesh_ali_power_strip
  asm misc: --cpreproc
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\app.sct
  link misc: --diag_suppress=L6314,L6312 --datacompressor off
  group include
    ../../../inc/platform/: rom_uuid.h
  group lib
    ../../../bin/: ROM.lib bee2_sdk.lib gap_utils.lib
    ../../../src/app/mesh/lib/lib/: mesh_dev.lib
  group cmsis
    ../../../src/mcu/rtl876x/arm/: startup_rtl8762c.s
    ../../../src/mcu/rtl876x/: system_rtl8762c.c
  group io
    ../../../src/mcu/peripheral/: rtl876x_io_dlps.c rtl876x_rcc.c rtl876x_tim.c rtl876x_uart.c rtl876x_gpio.c
  group profile
    ../../../src/app/mesh/lib/profile/: dfu_server.c dfu_client.c ota_server.c ais_server.c
    ../../../src/ble/profile/server/: dis.c
  group model
    ../../../src/app/mesh/lib/model/: health_server.c firmware_update_server.c object_transfer_server.c generic_on_off_server.c generic_power_on_off_server.c generic_power_on_off_setup_server.c generic_level_server.c generic_transition_time.c light_lightness_server.c light_lightness_setup_server.c light_ctl_server.c light_ctl_temperature_server.c light_hsl_server.c light_hsl_hue_server.c light_hsl_saturation_server.c light_hsl_setup_server.c generic_default_transition_time_server.c scene_server.c light_ctl_setup_server.c scene_setup_server.c delay_execution.c
    ../../../src/app/mesh/lib/model/realtek/: light_cwrgb_server.c
    ../../../src/app/mesh/lib/model/ali/: ali_model.c
  group app
    ../../../src/app/mesh/lib/common/: dfu_updater_app.c mp_cmd_parse.c light_effect_app.c light_storage_app.c light_cwrgb_app.c light_controller_app.c
    ../../../src/app/mesh/lib/utility/: dimmable_light.c
    ../../../src/app/mesh/lib/platform/: reset_watch_dog_timer.c
    ../../../src/mcu/rtl876x/: overlay_mgr.c
    ../../../src/app/mesh/ali_strip/: app_task.c main.c strip_app.c mp_cmd.c user_data.c strip_timer.c main_app.c
    ../../../src/flash/: silent_dfu_flash.c
    ../../../src/app/mesh/lib/model/: delay_msg_rsp.c
  group dlps_ctrl
    ../../../src/app/mesh/ali_strip/: light_swtimer.c light_dlps_ctrl.c
